FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://bootdelay.cfg \
"

SRC_URI += "file://bootdelay.cfg"
